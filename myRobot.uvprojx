# Keil uVision project myRobot.uvprojx, settings and files
target Robot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myRobot +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\Libraries\STM32F40x_StdPeriph_Driver\inc;.\Libraries\CMSIS;.\User;.\User\LCD;.\User\Remote;.\User\System;.\User\GPIO;.\User\PWM;.\User\Timer;.\User\MPU6050;.\User\Control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ./Libraries/CMSIS/startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ./Libraries/CMSIS/: cmsis_armcc.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group FWLib
    ./Libraries/STM32F40x_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ./User/: stm32f4xx_it.c system_stm32f4xx.c main.c tim.c PWM.c remote.c mpu6050.c encoder.c
    ./User/LCD/: lcd.c
    ./User/System/: delay.c sys.c usart.c
    ./User/GPIO/: GPIO.c EXIT.c
    ./User/Control/: control.c FindBall.c get_info.c
  group DOC
    ./Doc/: readme.txt
